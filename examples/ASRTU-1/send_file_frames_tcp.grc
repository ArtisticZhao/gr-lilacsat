options:
  parameters:
    author: lilac
    generate_options: qt_gui
    id: a222
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '8000'
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 192.168.31.11
    mtu: '10000'
    port: '52030'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {state: disabled}
- name: dslwp_attach_sync_marker_0
  id: dslwp_attach_sync_marker
  parameters:
    check_length: 'False'
    data_format: '2'
    marker: '[0x03, 0x22, 0x00, 0x00, 0x00]'
    msg_len: '0'
    pass_other_length: 'True'
  states: {}
- name: lilacsat_afsk1200_tx_f_0
  id: lilacsat_afsk1200_tx_f
  parameters:
    destination: BJ2CR-8
    maxoutbuf: '1024'
    msg_ptt_off: '[254, 254, 124, 224, 28, 0, 0, 253]'
    msg_ptt_on: '[254, 254, 124, 224, 28, 0, 1, 253]'
    padding_zero: 'False'
    ptt_mode: '1'
    repeater1: ''
    repeater2: ''
    source: BY2HIT-9
  states: {state: disabled}
- name: lilacsat_send_file_pdu_0
  id: lilacsat_send_file_pdu
  parameters:
    path: /home/lilac/111.grc
    pdu_len: '218'
    period: '3000'
    terminal: '0'
  states: {}

connections:
- [dslwp_attach_sync_marker_0, out, blocks_message_debug_0, print_pdu]
- [dslwp_attach_sync_marker_0, out, blocks_socket_pdu_0, pdus]
- [dslwp_attach_sync_marker_0, out, lilacsat_afsk1200_tx_f_0, in]
- [lilacsat_afsk1200_tx_f_0, '0', audio_sink_0, '0']
- [lilacsat_send_file_pdu_0, out, dslwp_attach_sync_marker_0, in]

metadata:
  file_format: 1
